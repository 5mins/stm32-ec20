# Keil uVision project EC20control.uvprojx, settings and files
target Phone (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: phone +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_USED,__FPU_PRESENT=1,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\USER;..\..\USER\FATFS;..\..\USER\BSP\SRAM;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;..\..\USER\BSP;..\..\USER\UCOSIII\uC-CPU;..\..\USER\UCOSIII\uC-LIB;..\..\USER\UCOSIII\uCOS_CONFIG;..\..\USER\UCOSIII\uCOS-III\Ports;..\..\USER\UCOSIII\uCOS-III\Source;..\..\USER\BSP\RTC;..\..\USER\STMWIN\Config;..\..\USER\STMWIN\inc;..\..\USER\STMWIN\OS;..\..\USER\EC20;..\..\USER\T9INPUT;..\..\USER\BSP\TTP226;..\..\USER\BSP\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/DSP_LIB/: arm_cortexM4lf_math.lib
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: stm32f4xx_it.c
    ../../USER/EC20/: ec20.c ec20.h web.c web.h
  group BSP
    ../../USER/Bsp/SPI/: spi_flash.c
    ../../USER/Bsp/usart/: bsp_debug_usart.c bsp_linkec20_usart.c
    ../../USER/Bsp/key/: bsp_key.c
    ../../USER/Bsp/LED/: led.c
    ../../USER/BSP/RTC/: rtc.c
    ../../USER/BSP/TIMER/: timer.c
    ../../USER/BSP/1.44TFT/: LCD_drive_hard.c LCD_SPI_hard.c
    ../../USER/BSP/: bsp.c bsp.h
    ../../USER/BSP/SRAM/: my_malloc_in.c
    ../../USER/BSP/TTP226/: TTP226.C TTP226.H
    ../../USER/BSP/adc/: bsp_adc.c bsp_adc.h
  group FATFS
    ../../USER/FATFS/: mycc936.c
  group DOC
    ../../Doc/: readme.txt
  group PUBLIC_FUNC
    ../../USER/Public_Func/: delay.c sys.c
  group Graph
    ../../USER/Graph1/: UCGUI_SAMPLE.c appicon.c
  group uC-CPU
    ../../USER/UCOSIII/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC-LIB
    ../../USER/UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOS_Config
    ../../USER/UCOSIII/uCOS_CONFIG/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uCOS-Ports
    ../../USER/UCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-Source
    ../../USER/UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group EMWIN_OS
    ../../USER/STMWIN/OS/: GUI_X_uCOS.c
  group EMWIN_INC
    ../../USER/STMWIN/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SIM_Win32.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIMTDRV_TangoC32.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group EMWIN_LIB
    ../../USER/STMWIN/Lib/: STemWin540_CM4_OS_Keil.lib STemWin540_CM4_OS_Keil_ARGB.lib STemWin540_CM4_OS_Keil_ot.lib STemWin540_CM4_OS_Keil_ot_ARGB.lib
  group EMWIN_CONFIG
    ../../USER/STMWIN/Config/: GUIConf.c GUIConf.h GUIDRV_Template.c GUIDRV_Template.h LCDConf.c LCDConf.h
  group FONTS
    ../../USER/UCG/GUI/Font/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUICharPEx.c EmWin_ASCII_Font.h EmWinHZFont.h GUI_UC_EncodeNone.c
  group PINGYING
    ../../USER/T9INPUT/: pyinput.c pyinput.h pymb.h
